# Keil uVision project 倒立摆.uvprojx, settings and files
target 测试 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 倒立摆 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\CORE;..\HARDWARE;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group 用户
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group 硬件
    ../HARDWARE/LED/: led.c
    ../HARDWARE/: pwm.c adc.c encoder.c control.c motor.c stmflash.c OLED_I2C.c
  group 系统
    ../HARDWARE/: exti.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/: tim2.c
  group 核心&启动
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group 函数库
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_flash.c
